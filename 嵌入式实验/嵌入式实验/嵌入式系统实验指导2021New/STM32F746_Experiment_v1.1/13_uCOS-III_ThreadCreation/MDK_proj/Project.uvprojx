# Keil uVision project Project.uvprojx, settings and files
target STM32F746_Experiment (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746_Experiment +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_480x272,PUTCHAR_ON_COM,VECT_TAB_SRAM
  c misc: --C99
  c include: ..\Inc;..\BSP;..\BSP\OS\uCOS-III;..\..\Common\BSP;..\..\Common\Driver;..\..\Common\CMSIS;..\..\Common\Initialize;..\..\Common\Middlewares\uCOS-III\uCOS-III\Source;..\..\Common\Middlewares\uCOS-III\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\Common\Middlewares\uCOS-III\uC-CPU;..\..\Common\Middlewares\uCOS-III\uC-CPU\ARM-Cortex-M4\RealView;..\..\Common\Middlewares\uCOS-III\uC-LIB;..\..\Common\Middlewares\uCOS-III\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\Common\Middlewares\uCOS-III\uC-Serial\Driver\ST;..\..\Common\Middlewares\uCOS-III\uC-Serial\Line;..\..\Common\Middlewares\uCOS-III\uC-Serial\OS;..\..\Common\Middlewares\uCOS-III\uC-Serial\Source;..\..\Common\Middlewares
  library: MicroLIB
  memory RVCT4: ROM 0x20010000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\STM32F746_Experiment.sct
  link misc: --diag_suppress=L6329
  group Startup
    ./: startup_stm32f756xx.s
  group Common
    ../../Common/Middlewares/: lcd_log.c
    ../../Common/BSP/: stm32756g_eval.c stm32756g_eval_sdram.c stm32756g_eval_lcd.c stm32756g_eval_io.c
    ../../Common/Driver/: stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_hcd.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c
    ../../Common/CMSIS/: system_stm32f7xx.c
  group uCOS
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c cpu_bsp.c serial_bsp_stm32f7xx.c serial_bsp_stm32f7xx.h
    ../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
    ../../Common/Middlewares/uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../Common/Middlewares/uCOS-III/uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../Common/Middlewares/uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../Common/Middlewares/uCOS-III/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
    ../../Common/Middlewares/uCOS-III/uC-Serial/Source/: serial.c serial.h serial_buf.c serial_buf.h serial_type.h
    ../../Common/Middlewares/uCOS-III/uC-Serial/OS/uCOS-III/: serial_os.c
    ../../Common/Middlewares/uCOS-III/uC-Serial/OS/: serial_os.h
    ../../Common/Middlewares/uCOS-III/uC-Serial/Line/: serial_line_dflt.c serial_line_dflt.h serial_line_probe.c serial_line_probe.h serial_line_tty.c serial_line_tty.h
    ../../Common/Middlewares/uCOS-III/uC-Serial/Driver/ST/: serial_drv_stm32.c serial_drv_stm32.h
    ../../Common/Middlewares/uCOS-III/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../Common/Middlewares/uCOS-III/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group Source
    ../Src/: stm32f7xx_it.c app.c app_serial.c os_app_hooks.c
  group Document
    ../Doc/: readme.txt
