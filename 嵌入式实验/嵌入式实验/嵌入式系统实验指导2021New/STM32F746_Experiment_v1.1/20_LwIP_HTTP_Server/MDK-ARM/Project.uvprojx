# Keil uVision project Project.uvprojx, settings and files
target STM32F746_Experiment (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746_Experiment +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER,USE_480x272,VECT_TAB_SRAM
  c misc: --C99
  c include: ..\Inc;..\..\Common\CMSIS;..\..\Common\Driver;..\..\Common\BSP;..\..\Common\Middlewares\LwIP\src\include\;..\..\Common\Middlewares\LwIP\src\include\ipv4;..\..\Common\Middlewares\LwIP\system;..\..\Common\Middlewares;..\..\Common\Initialize
  library: MicroLIB
  memory RVCT4: ROM 0x20010000 size 0x20000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20030000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\STM32F746_Experiment.sct
  link misc: --diag_suppress=L6329
  group Startup
    ../../Common/Startup/: startup_stm32f756xx.s
  group Common
    ../../Common/Driver/: stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c.c stm32f7xx_hal_adc.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal.c stm32f7xx_hal_sdram.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_ltdc.c
    ../../Common/BSP/: stm32756g_eval.c stm32756g_eval_lcd.c stm32756g_eval_sdram.c stm32756g_eval_io.c
    ../../Common/Components/mfxstm32l152/: mfxstm32l152.c
    ../../Common/Components/stmpe811/: stmpe811.c
    ../../Common/Middlewares/: lcd_log.c
    ../../Common/CMSIS/: system_stm32f7xx.c
  group LwIP
    ../../Common/Middlewares/LwIP/src/api/: api_msg.c sockets.c api_lib.c netdb.c err.c netbuf.c tcpip.c netifapi.c
    ../../Common/Middlewares/LwIP/src/core/: tcp_in.c init.c stats.c pbuf.c raw.c tcp.c lwip_timers.c sys.c dhcp.c tcp_out.c def.c dns.c memp.c mem.c netif.c udp.c
    ../../Common/Middlewares/LwIP/src/core/ipv4/: igmp.c inet_chksum.c autoip.c ip.c inet.c ip_frag.c ip_addr.c icmp.c
    ../../Common/Middlewares/LwIP/src/netif/: etharp.c
  group Source
    ../Src/: main.c httpd_cgi_ssi.c ethernetif.c httpd.c fs.c stm32f7xx_it.c app_ethernet.c stm32f7xx_hal_msp.c
  group Doc
    ../Doc/: readme.txt
