# Keil uVision project Project.uvprojx, settings and files
target STM32F746_Experiment (ARM-ADS)
  device: ARMCM7 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M7") CLOCK(12000000) ESEL ELITTLE
  output: STM32F746_Experiment +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER,VECT_TAB_SRAM
  c misc: --C99
  c include: ..\Inc;..\..\Common\BSP;..\..\Common\Driver;..\..\Common\CMSIS;..\..\Common\Initialize
  asm define: VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\STM32F746_Experiment.sct
  link misc: --diag_suppress=L6329
  group Startup
    ../../Common/Startup/: startup_stm32f756xx.s
  group Common
    ../../Common/BSP/: stm32756g_eval.c stm32756g_eval_io.c
    ../../Common/Driver/: stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_msp.c
    ../../Common/Initialize/: system_init.c
    ../../Common/CMSIS/: system_stm32f7xx.c
    ../../Common/Components/mfxstm32l152/: mfxstm32l152.c
  group Source
    ../Src/: main.c config.c stm32f7xx_it.c
  group Document
    ../Doc/: readme.txt
