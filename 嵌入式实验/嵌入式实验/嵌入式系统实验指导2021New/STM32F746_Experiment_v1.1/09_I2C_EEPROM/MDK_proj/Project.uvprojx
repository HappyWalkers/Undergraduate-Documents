# Keil uVision project Project.uvprojx, settings and files
target STM327x6G_EVAL (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746_Experiment
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F756xx,USE_STM32756G_EVAL,USE_IOEXPANDER,VECT_TAB_SRAM
  c misc: --C99
  c include: ..\Inc;..\..\Common\BSP;..\..\Common\CMSIS;..\..\Common\Initialize;..\..\Common\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x20010000 size 0x10000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Startup
    ./: startup_stm32f756xx.s
  group Common
    ../../Common/BSP/: stm32756g_eval.c stm32756g_eval_io.c
    ../../Common/Components/mfxstm32l152/: mfxstm32l152.c
    ../../Common/Driver/: stm32f7xx_hal_dma.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_gpio.c
    ../../Common/CMSIS/: system_stm32f7xx.c
  group Source
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c main.c
  group Doc
    ../Doc/: readme.txt
