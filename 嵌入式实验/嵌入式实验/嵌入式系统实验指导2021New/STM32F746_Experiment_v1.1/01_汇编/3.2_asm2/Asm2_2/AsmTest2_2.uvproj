# Keil uVision project AsmTest2_2.uvproj, settings and files
target AsmTest2_2 (ARM-ADS)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: AsmTest2_2
  c flags: Optim=1
  memory RVCT1: ROM 0x0 size 0x2000000
  memory RVCT6: RAM 0x30000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source
    ./: asm_code2.s
  group Script
    ./: DebugInRam.ini
  group ReadMe
    ./: readme.txt
    ../../common/: ReadMeCommon.txt
