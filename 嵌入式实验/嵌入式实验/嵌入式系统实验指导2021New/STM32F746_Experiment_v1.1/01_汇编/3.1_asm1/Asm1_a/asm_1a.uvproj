# Keil uVision project asm_1a.uvproj, settings and files
target asm1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: S3C2410A Samsung
  cpu: IRAM(0x40000000-0x40001FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: asm1
  c flags: v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT1: ROM 0x0 size 0x2000000
  memory RVCT6: RAM 0x30000000 size 0x4000000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source
    ./: asm1_a.s
  group Script
    ./: DebugINRam.ini
  group ReadMe
    ./: readme.txt
    ../../common/: ReadMeCommon.txt
