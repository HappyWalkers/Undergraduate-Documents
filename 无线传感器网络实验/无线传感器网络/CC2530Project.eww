<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>C:\Users\admin\Desktop\CC2530Project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


