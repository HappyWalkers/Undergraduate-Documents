# IAR project protocal.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
configuration Release (8051)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  group (top)
    ./: APP_Base.c APP_Base.h irdist.c protocal.c SAPP_Device.c SAPP_Device.h SAPP_FrameWork.c SAPP_FrameWork.h
