<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>E:\&#x5149;&#x76D8;&#x8D44;&#x6599;V1.2.0&#xFF08;&#x4e2D;&#x5357;&#x5927;&#x5B66;&#xFF09;\&#x5B9e;&#x9A8C;&#x6307;&#x5BFC;&#x4e66;\&#x5B9e;&#x9A8C;&#x7BB1;&#x5B9e;&#x9A8C;-Linux&#x5e73;&#x53F0;&#x7BC7;\Code\Cap1_Basic\Ex09_ControlModule\ControlModule\ControlModule.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\protocal\protocal.ewp</path>
  </project>
  <project>
    <path>E:\&#x5149;&#x76D8;&#x8D44;&#x6599;V1.2.0&#xFF08;&#x4e2D;&#x5357;&#x5927;&#x5B66;&#xFF09;\&#x5B9e;&#x9A8C;&#x6307;&#x5BFC;&#x4e66;\&#x5B9e;&#x9A8C;&#x7BB1;&#x5B9e;&#x9A8C;-Linux&#x5e73;&#x53F0;&#x7BC7;\Code\Cap2_ZStack\ZStack-CC2530-r200\Projects\SappWsn\SappWsn.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Sensor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


