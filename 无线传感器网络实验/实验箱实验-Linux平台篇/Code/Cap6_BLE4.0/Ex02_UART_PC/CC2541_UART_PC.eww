<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CC2541_UART_PC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


